<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\xxx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\2\xxx.ewp</path>
  </project>
  <batchBuild/>
</workspace>


